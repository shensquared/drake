Commit message: ROS side inertia, penetration stiffness, damping, and friction fix.

File: drake/automotive/models/prius/prius.urdf (robot description, URDF)
Before this commit: robot prius_1, 14 links, 13 joints
Links:
- link chassis_floor: mass 57.833 -> 1360
